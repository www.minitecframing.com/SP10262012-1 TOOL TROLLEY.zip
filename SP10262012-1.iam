# Autodesk Inventor assembly: SP10262012-1
## iProperties
Created: 2012-10
Part Number: SP10262012-1
Document SubType Name: Assembly
Designer: Administrator
Author: Administrator
